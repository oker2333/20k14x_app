# IAR project 20k14x_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K148M ZhiXin Z20K148M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEV_Z20K148M
  ICCARM.CCIncludePath2: ..\StdDriver\Inc; ..\TOOL; ..\I2C; ..\I2S; ..\ADC; ..\CAN; ..\CMP; ..\CMU; ..\CRC; ..\EIRU; ..\EWDT; ..\FLASH; ..\GPIO; ..\MCPWM; ..\PARCC; ..\PMU; ..\RTC; ..\SCC; ..\SCM; ..\SMPU; ..\SPI; ..\SRMC; ..\TIMER; ..\UART; ..\WDOG; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 20k14x_app.srec
  ILINK.IlinkOutputFile: 20k14x_app.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: 20k14x_app.c
  group Device
    ../: register.h
    ../Device/: Z20K148M_startup.s
  group I2C_APP
    ../: i2c_app.c i2c_dma_rx_dma_tx.c i2c_dma_rx_int_tx.c i2c_dma_rx_polling_tx.c i2c_int_rx_int_tx.c i2c_int_rx_polling_tx.c i2c_polling_rx_int_tx.c i2c_polling_rx_polling_tx.c vl6180x_driver.c vl6180x_driver.h vl6180x_driver_app.c
  group I2C_APP/I2C
    ../I2C/: z20k14x_i2c.c z20k14x_i2c.h
  group I2S_APP
    ../: i2s_app.c
  group STD_Driver
    ../StdDriver/Src/: adc_drv.c aes_drv.c can_drv.c clock_drv.c cmp_drv.c cmu_drv.c crc_drv.c dma_drv.c eiru_drv.c ewdt_drv.c flash_drv.c gpio_drv.c i2c_drv.c i2s_drv.c int_drv.c mcpwm_drv.c pmu_drv.c regfile_drv.c rtc_drv.c scm_drv.c seru_drv.c smpu_drv.c spi_drv.c srmc_drv.c stim_drv.c sysctrl_drv.c tdg_drv.c tim_drv.c tmu_drv.c trng_drv.c uart_drv.c wdog_drv.c
  group Tools
    ../TOOL/: clock_config.c clock_config.h parity_bit.c parity_bit.h read.c serial.c serial.h write.c
